<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L432CK_IR_TX_RX.ewp</path>
  </project>
  <batchBuild />
</workspace>
